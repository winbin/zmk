## app/boards/shields/bigo40/Kconfig.shield
```kconfig
# Copyright (c) 2022 The ZMK Contributors
# SPDX-License-Identifier: MIT

config SHIELD_BIGO40
    def_bool $(shields_list_contains,bigo40)
```
